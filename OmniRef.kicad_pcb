# Repository NathanSchenk/OmniRef

File README.md:

# OmniRef
A universal voltage reference

<br />This work is licensed under a <a rel="license" href="http://creativecommons.org/licenses/by-sa/4.0/">Creative Commons Attribution-ShareAlike 4.0 International License</a>.

## KiCad design OmniRef.kicad_pcb

Parts:
BT1: Battery; 9vClipWireLeads
C1, C3, C4, C5, C10: 1uF; C_0805_HandSoldering
C2, C6, C7, C8, C11, C13: 10uF; C_0805_HandSoldering
C9: 10uF; CP_Tantalum_Case-C_EIA-6032-28_Hand
C12: 10pF; C_0805_HandSoldering
D1, D2, D3, D9: SMA; D_SMA
D5, D7: LED; LED_1206_2.15mmHole
D6: 12V; D_SMA
D8: D_Schottky; D_SMA
J1: 4mm Banana Jack Pair; Banana_Jack_2pin_Wings_45M_.25_.75
J2: 4mm Banana Jack Pair; Banana_Jack_2pin_Wings_.25_.75
L1: L; Inductor_Taiyo-Yuden_NR-60xx_HandSoldering
Q1: PMBT3906; SOT-23
R1, R8: 10K; R_0805_HandSoldering
R2: 470K; R_0805_HandSoldering
R3, R5: 100K; R_0805_HandSoldering
R4, R6, R9: 1; R_0805_HandSoldering
R7, R10: 3.6K; R_0805_HandSoldering
R11: 0; R_0805_HandSoldering
R12: 1M; R_0805_HandSoldering
R13: 82K; R_0805_HandSoldering
RV1: 10K; Potentiometer_Trimmer_Bourns_3224W
SW1: SW_DPDT_x2; CnK_L_Series_DPDT
U1: REFERENCE IC; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: LP2951; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: REFERENCE IC; DIP-8_W7.62mm
U4: AP3015; SOT-23-5_HandSoldering

Connections:
BAT+: C12.1, C13.1, D8.1 (K), R11.1, R12.1, SW1.3
ER: R5.2, U2.5 (~ERROR)
GND: BT1.0, BT1.2 (-), C1.2, C2.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C13.2, D6.2 (A), D9.2 (A), J1.2, J2.2, R1.2, R6.2, R7.2, R8.2, R10.2, R13.2, RV1.1, U1.4 (GND), U2.3 (SHTD), U2.4 (GND), U3.4 (GND), U4.2 (GND)
unnamed: BT1.1 (+), D9.1 (K), R11.2, SW1.6
unnamed: C2.1, D3.1 (K), SW1.2, U2.8 (IN)
unnamed: C3.2, R1.1, R3.2, U2.7 (FEEDBACK)
unnamed: C4.1, U1.8 (NR), U3.8 (NR)
unnamed: C5.1, R2.2, U1.5 (TRIM), U3.5 (TRIM)
unnamed: C6.1, R4.2
unnamed: C7.1, C8.1, C9.1, D2.2 (A), D6.1 (K), J2.1, R8.1, RV1.3, U1.6 (Vout), U3.6 (Vout)
unnamed: C7.2, R6.1
unnamed: C10.1, R9.2, U1.3 (TEMP), U3.3 (TEMP)
unnamed: C11.1, L1.1, SW1.5, U4.4 (~SHTD), U4.5 (IN)
unnamed: C12.2, R12.2, R13.1, U4.3 (FB)
unnamed: D1.1 (K), SW1.1
unnamed: D1.2 (A), J1.1
unnamed: D5.1 (K), R7.1
unnamed: D5.2 (A), Q1.3 (C)
unnamed: D7.1 (K), R10.1
unnamed: D8.2 (A), L1.2, U4.1 (SW)
unnamed: Q1.1 (B), R5.1
unnamed: R2.1, RV1.2
V+: C1.1, C3.1, D2.1 (K), D3.2 (A), D7.2 (A), Q1.2 (E), R3.1, R4.1, R9.1, U1.2 (Vin), U2.1 (OUT), U3.2 (Vin)

Notes on the sheet:
Adjust R1 and R3 values to provide approximately 2v above reference output voltage. With R3 at 100K and R1 at 10K, the voltage should be about 13.58V Adjust R7 and R10 value to light LED with reasonable brightness for the voltage chosen. 3mA seems to be about right for the LED brightness.
R9 is only used for certain Linear Technology IC's. C10 is only used for certain Maxim Integrated IC's. C4 and C5 are optional stability improving capacitors. Check the datasheet of the reference to see if one should be used. R2 and RV1 are to trim the output voltage on certain references.
D6 is intended to clamp the output voltage if driven from an external source. It also provides reverse voltage protection. R8 is to provide a fixed load for the regulator to work against and is probably not needed. Only one output bypass cap is really needed. The different ones shown just provide o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
With R12 at 1M and R13 at 82K, Bat+ should be 16.23V
R11 is only populated if switching stage is not used.

Board: 2 copper layers, 79.5 x 50.4 mm, 45 parts (41 on the bottom side), 23 nets.

## Commit log

2017-12-17 Renamed to OmniRef. Made some final changes to schematic and board before generating gerbers.
2017-12-17 Generated Gerbers. Fixed a couple unconnected pads the DRC found.
2017-12-17 Generated gerber.zip. Ordered prototype boards from seeed.
2017-12-19 Added DC-DC converter front end. Adjusted some logos and stuff.
2017-12-19 Generated gerbers for new layout.
2017-12-25 Adjusted size of outline to improve board fit.
2017-12-25 Selected resistors for switching regulator. Fixed SW1 wiring.
2017-12-27 Fixed a number of issues discovered during prototyping. Re-arranged logos a bit.
    Moved RV1 between output jacks to clear battery.
2017-12-27 Adjusted OSHW logo.
    Made PDF's of the schematic and board.
2017-12-27 Created battery holder and insulator .dxf's for laser cutting.
    1.75mm acrylic sheet worked very well.
2017-12-27 Added holes for potentiometer in insulator plate.
2018-01-04 Added some resistors to "expand the scale" of RV1. Made some other minor modifications.
    Added to the BOM.
